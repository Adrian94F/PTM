# Keil uVision project lab3-timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: SAB 80C537 Infineon
  cpu: IRAM(0-0xFF) CLOCK(16000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: lab3-timer
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab3-timer.asm
